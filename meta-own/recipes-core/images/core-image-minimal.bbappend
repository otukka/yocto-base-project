IMAGE_INSTALL_append = " open-amp"
IMAGE_INSTALL_append = " libmetal"
IMAGE_INSTALL_append = " app"

IMAGE_INSTALL_append_zcu111-zynqmp = " rfdc"
